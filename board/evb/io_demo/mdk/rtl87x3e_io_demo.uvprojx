# Keil uVision project rtl87x3e_io_demo.uvprojx, settings and files
target io_demo_4M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: io_demo +hex
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M "0" rtl87x3e
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M rtl87x3e
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PRE_UPPERSTACK=1 NOT_SUPPORT_UPPERSTACK TARGET_RTL87X3E = 1
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\io;..\..\io_demo;..\..\..\..\src\sample\io_demo\ir\protocol;..\..\..\..\src\mcu\rtl87x3;..\..\..\..\inc\rtl87x3e\hal\;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\inc\rtl87x3e;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\src\sample\io_demo\rtc\clock;..\..\..\..\inc\hal\platform;..\..\..\..\inc\hal\power;..\..\..\..\src\sample\io_demo\sdio\demo\fatfs\src;..\..\..\..\src\mcu\module\rtc_calendar;..\mdk;..\..\..\..\src\mcu\module\ir_detect_pulse
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e_io_demo.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../../bin/rtl87x3e/: ROM.lib hal_utils.lib sd.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group io_driver
    ../../../../src/mcu/io/rtl87x3e/: rtl876x_keyscan.c
  group app
    ../../../../src/sample/io_demo/: main.c
  group adc
    ../../../../src/sample/io_demo/adc/one-shot/: adc_demo.c adc_polling_demo.c
    ../../../../src/sample/io_demo/adc/adc_charger_demo/: adc_charger_demo.c
    ../../../../src/sample/io_demo/adc/adc_continuous_mode/: adc_continuous_mode_demo.c
    ../../../../src/sample/io_demo/adc/adc_hw_average/: adc_hw_average_demo.c
    ../../../../src/sample/io_demo/adc/adc_manger/: adc_manager_demo.c
    ../../../../src/sample/io_demo/adc/adc_key/: adc_key_demo.c
  group gdma
    ../../../../src/sample/io_demo/gdma/adc_dma/: adc_gdma_demo.c
    ../../../../src/sample/io_demo/gdma/i2c_dma/MasterRx+SlaveTx/: i2c_dma_demo.c
    ../../../../src/sample/io_demo/gdma/memtomem/: gdma_demo.c
    ../../../../src/sample/io_demo/gdma/multiblock/: dma_multiblock_demo.c
    ../../../../src/sample/io_demo/gdma/multiblock_tim_gpio/: dma_tim_demo.c
    ../../../../src/sample/io_demo/gdma/scatter_gather/: dma_scrgar_demo.c
    ../../../../src/sample/io_demo/gdma/uart_idle_rx/: uart_rx_dma.c
    ../../../../src/sample/io_demo/gdma/uart_tx/: uart_tx_gdma.c
    ../../../../src/sample/io_demo/gdma/spi_dma/: spi_dma_demo.c
  group gpio
    ../../../../src/sample/io_demo/gpio/input/: gpio_input_demo.c
    ../../../../src/sample/io_demo/gpio/interrupt/: gpio_int_demo.c pad_int_demo.c
    ../../../../src/sample/io_demo/gpio/key/level_tim/: gpio_key.c
    ../../../../src/sample/io_demo/gpio/key/edge/: gpio_edge_key.c
    ../../../../src/sample/io_demo/gpio/output/: gpio_output_demo.c hal_gpio_open_drain_demo.c
    ../../../../src/sample/io_demo/dlps/: dlps_gpio_wk_demo.c
  group i2c
    ../../../../src/sample/io_demo/i2c/interrupt/: i2c_demo.c
    ../../../../src/sample/io_demo/i2c/master_write/: i2c_mw_demo.c
    ../../../../src/sample/io_demo/i2c/polling/: i2c_polling_demo.c
    ../../../../src/sample/io_demo/i2c/slave/: i2c_slave_demo.c
  group ir
    ../../../../src/sample/io_demo/ir/protocol/: ir_nec_protocol.c
    ../../../../src/sample/io_demo/ir/receive/: ir_receive_demo.c
    ../../../../src/sample/io_demo/ir/pulse_detection/: ir_pulse_detection_demo.c
    ../../../../src/sample/io_demo/ir/send/: ir_send_interrupt_demo.c ir_send_polling_mode_demo.c
    ../../../../src/mcu/module/ir_detect_pulse/: ir_detect_pulse.c
    ../../../../src/sample/io_demo/ir/detect_pulse_demo/: ir_detect_pulse_demo.c
  group keyscan
    ../../../../src/sample/io_demo/keyscan/active/: keyscan_demo.c
    ../../../../src/sample/io_demo/keyscan/dlps/: keyscan_demo_dlps.c
  group led
    ../../../../src/sample/io_demo/led/: led_demo_task.c sleep_led_demo.c sw_led_demo.c
  group lpc
    ../../../../src/sample/io_demo/lpc/comparator/: lpc_comparator_demo.c
    ../../../../src/sample/io_demo/lpc/voltage_detection/: lpc_rtc_vol_demo.c lpc_peri_vol_demo.c
  group qdec
    ../../../../src/sample/io_demo/qdec/: qdec_demo.c
  group rtc
    ../../../../src/sample/io_demo/rtc/comparator/: rtc_demo.c
    ../../../../src/sample/io_demo/rtc/overflow/: rtc_overflow_demo.c
    ../../../../src/sample/io_demo/rtc/tick/: rtc_tick_demo.c
    ../../../src/sample/io_demo/rtc/clock/: rtc_clock_demo.c
    ../../../../src/sample/io_demo/rtc/power_down/: rtc_in_power_down_mode.c
    ../../../../src/mcu/module/rtc_calendar/: rtc_calendar.c
    ../../../../src/sample/io_demo/rtc/calendar_demo/: rtc_calendar_demo.c
    ../../../../src/sample/io_demo/rtc/dlps/: rtc_in_dlps_mode.c
  group sdio
    ../../../../src/sample/io_demo/sdio/sdcard/: sdio_demo.c sdio_card_detect_demo.c
    ../../../../src/sample/io_demo/sdio/demo/: sdio_fs_demo.c
    ../../../../src/sample/io_demo/sdio/demo/fatfs/src/: diskio.c ff.c ffsystem.c ffunicode.c
  group spi
    ../../../../src/sample/io_demo/spi/dynamic_switch_cs/: spi_switchcs_demo.c
    ../../../../src/sample/io_demo/spi/interrupt/: spi_master_demo.c spi_rgb_interrupt_demo.c
    ../../../../src/sample/io_demo/spi/polling/: spi_demo.c spi_rgb_polling_demo.c
    ../../../../src/sample/io_demo/spi/slave/: spi_slave_demo.c spi_slave_gpio_demo.c spi_slave_write_demo.c spi_slave_rx_dma_hs_demo.c spi_slave_tx_dma_hs_demo.c
    ../../../../src/sample/io_demo/spi/eeprom/: spi_master_eeprom_mode_demo.c
    ../../../../src/sample/io_demo/spi/receive_only/: spi_master_rx_only_mode_demo.c
    ../../../../src/sample/io_demo/spi/spi2spi_auto_reload_dma/: spi2spi_auto_reload_dma_demo.c
    ../../../../src/sample/io_demo/spi/spi2spi_dma/: spi2spi_dma_demo.c
    ../../../../src/sample/io_demo/spi/dlps/: spi_dlps_demo.c spi_master_tx_dma_dlps_demo.c spi_dlps_slave_rx_dma_demo.c spi_dlps_slave_rx_dma_gpio_demo.c
    ../../../../src/sample/io_demo/gdma/spi_dma/: spi_rgb_dma_demo.c spi_master_tx_dma_demo.c
  group tim
    ../../../../src/sample/io_demo/tim/interrupt/: tim_demo.c
    ../../../../src/sample/io_demo/tim/pwm/: pwm_demo.c
  group uart
    ../../../../src/sample/io_demo/uart/dlps/: dlps_uart_demo.c
    ../../../../src/sample/io_demo/uart/hw_flow_control/: uart_fc_demo.c
    ../../../../src/sample/io_demo/uart/interrupt/: uart_demo.c uart_tx_demo.c
    ../../../../src/sample/io_demo/uart/polling/: uart_polling_demo.c
    ../../../../src/sample/io_demo/adp_1wire/: adp_1wire_uart_demo.c
  group ctc
    ../../../../src/sample/io_demo/captouch/: cap_touch_demo.c
  group i2s
    ../../../../src/sample/io_demo/i2s/dma_operation/: i2s_master_dma_operation_demo.c
    ../../../../src/sample/io_demo/i2s/master_recv/: i2s_master_recv_demo.c
    ../../../../src/sample/io_demo/i2s/master_send/: i2s_master_send_demo.c
    ../../../../src/sample/io_demo/i2s/slave_recv/: i2s_slave_recv_demo.c
  group spi_external_flash
    ../../../../src/sample/io_demo/spi/external_flash/: external_flash.c external_flash_test.c
target io_demo_2M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: io_demo +hex
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 2M "0" rtl87x3e
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_2M rtl87x3e
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PRE_UPPERSTACK=1 NOT_SUPPORT_UPPERSTACK CONFIG_SOC_SERIES_RTL8763E
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\rtl87x3e\io;..\..\io_demo;..\..\..\..\src\sample\io_demo\ir\protocol;..\..\..\..\src\mcu\rtl87x3;..\..\..\..\inc\rtl87x3e\hal\;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\inc\rtl87x3e;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\rtl87x3e\hal\io;..\..\..\..\inc\hal\io;..\..\..\..\inc\hal\platform;..\..\..\..\inc\hal\power;..\..\..\..\src\sample\rws;..\..\..\..\src\mcu\sd_mgr\sd_lib;..\..\..\..\src\mcu\sd_mgr\config;..\..\..\..\src\sample\io_demo\sdio\demo\fatfs\src;..\..\..\..\src\mcu\module\rtc_calendar;..\mdk;..\..\..\..\src\mcu\module\ir_detect_pulse
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e_io_demo.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target io_demo_16M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: io_demo +hex
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M "0" rtl87x3e
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_16M rtl87x3e
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PRE_UPPERSTACK=1 NOT_SUPPORT_UPPERSTACK TARGET_RTL87X3E = 1
  c misc: --gnu --bss_threshold=0
  c include: as above
  asm misc: --cpreproc
  asm include: ..\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e_io_demo.sct
  link misc: --diag_suppress=L6314 --datacompressor off
