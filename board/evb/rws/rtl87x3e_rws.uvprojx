# Keil uVision project rtl87x3e_rws.uvprojx, settings and files
target rws_4M_dual_bank0_ANC_Gaming (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rws
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e stereo all gaming_stereo
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8763EWM = 1 TARGET_LEGACY_AUDIO_GAMING=1
  c misc: --gnu --bss_threshold=0 --no_branch_tables  --diag_suppress=177 --preinclude app_flags.h --preinclude app_lea_flags.h --preinclude ble_audio_flags.h
  c include: .\inc\rtl87x3e_ewm;..\rws;..\..\..\inc\app;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\stack;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\platform;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\platform\console;..\..\..\inc\framework;..\..\..\inc\framework\sys;..\..\..\inc\framework\audio;..\..\..\inc\framework\mmi;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\rtl87x3e\hal;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\leaudio;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\service;..\..\..\inc\service\gfps;..\..\..\inc\service\bisto;..\..\..\inc\service\xiaoai;..\..\..\inc\service\xiaowei;..\..\..\inc\service\ama;..\..\..\inc\service\teams;..\..\..\inc\service\teams\asp_device;..\..\..\inc\service\teams\hid;..\..\..\inc\service\teams\ble;..\..\..\src\mcu\module\led;..\..\..\inc\hal\power;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\mcu\rtl876x;..\..\..\src\mcu\module\vector;..\..\..\src\mcu\module\stream;..\..\..\src\mcu\usb\inc;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\ble\gatt_client;..\..\..\src\debug;..\..\..\src\sample\rws;..\..\..\src\sample\rws\local_playback;..\..\..\src\sample\rws\local_playback\sd_emmc;..\..\..\src\sample\rws\bqb;..\..\..\src\sample\rws\console;..\..\..\src\sample\rws\cli;..\..\..\src\sample\rws\bud;..\..\..\src\sample\rws\mp;..\..\..\src\sample\rws\app;..\..\..\src\sample\rws\engage;..\..\..\src\sample\rws\gfps;..\..\..\src\sample\rws\xiaoai;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\ama;..\..\..\src\sample\rws\eq;..\..\..\src\sample\rws\dongle;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\teams\asp_device;..\..\..\src\sample\rws\teams\hid;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\teams\cfu;..\..\..\src\sample\rws\teams\cfu\Signature;..\..\..\src\sample\rws\xiaowei;..\..\..\src\sample\rws\lea;..\..\..\src\sample\rws\usb_audio;..\..\..\src\sample\rws\usb_cfu;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\ble_mgr;..\..\..\src\sample\rws\usb\audio;..\..\..\src\sample\rws\usb\hid;..\..\..\src\sample\rws\usb;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_app;..\..\..\src\sample\rws\tuya\tuya_enc\mbedtls;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_port;..\..\..\src\sample\rws\tuya\tuya_ble_sdk;..\..\..\src\sample\rws\tuya\tuya_enc;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\io;..\..\..\src\mcu\module\console\transport;..\..\..\src\sample\rws\ha;..\..\..\src\sample\rws\speaker;..\..\..\inc\hal\platform;..\..\..\src\sample\rws\findmy;..\..\..\src\sample\rws\findmy\fmna;..\..\..\src\sample\rws\findmy\fmna\platform;..\..\..\src\sample\rws\findmy\ble_platform;..\..\..\src\sample\common\findmy\crypto\third_party\mbedtls;..\..\..\src\sample\common\findmy\crypto\fmna-crypto-wrapper-reference\include;..\..\..\src\sample\common\findmy\crypto;..\..\..\src\sample\common\findmy\crypto\wolfssl\wolfcrypt\src;..\..\..\src\sample\common\findmy\crypto\wolfssl\wolfssl\wolfcrypt;..\..\..\src\sample\common\findmy\crypto\third-party;..\..\..\src\sample\common\findmy\crypto\wolfssl;..\..\..\src\sample\rws\findmy\ble_profile;..\..\..\src\sample\rws\test;..\..\..\src\sample\common;..\..\..\inc\rtl87x3e\hal\stack;..\..\..\src\ble\bt_gatt_svc;..\..\..\inc\ble_mgr\bond;..\..\..\inc\usb;..\..\..\inc\usb\bc12;..\..\..\inc\usb\class;..\..\..\inc\usb\composite;..\..\..\inc\usb\hal;..\..\..\src\sample\common\app_ble_service;..\..\..\src\sample\rws\lea;..\..\..\src\sample\rws\bond;..\..\..\src\sample\common\usb
  asm misc: --cpreproc
  asm include: .\inc\rtl87x3e_ewm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cfg\rtl87x3e\rtl87x3e_rws_ewm_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ./: config.h
    ../../../src/sample/rws/: app_flags.h
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../bin/rtl87x3e/: gap_utils.lib ROM.lib framework.lib hal_utils.lib engage.lib upperstack_2M.lib upperstack_4M.lib ble_mgr.lib leaudio.lib gfps.lib teams.lib tuya_ble_sdk_v2.0.0_lib_arm_m3_keil.lib xiaoai.lib xiaoai_auth_lib.lib xiaowei.lib dual_audio_effect.lib usb_hal.lib usb.lib gaming_bt.lib
    ../../../src/sample/rws/teams/cfu/Signature/: CryptoLibECC.lib
    ../../../bin/rtl87x3e/spatial_audio_sensor/Lib/: CWM_LIB_Keil_m3.lib
    ../../../bin/rtl87x3e/spatial_audio_sensor/vq/Lib/: CWM_LIB_Keil_m3_vq.lib
    ../../../bin/rtl87x3e/framework/: console.lib sysm.lib remote.lib
  group cmsis
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group io
    ../../../src/sample/rws/: app_sensor_iqs773_873.c app_vendor_iqs773_873.c
  group module
    ../../../src/mcu/module/led/: led_module.c
    ../../../src/mcu/module/stream/: ble_stream.c iap_stream.c spp_stream.c common_stream.c
    ../../../src/mcu/module/vector/: vector.c
    ../../../src/sample/rws/: image_header.c
  group console
    ../../../src/mcu/module/console/transport/: console_uart.c
  group cli
    ../../../src/sample/rws/cli/: cli_cfg_cmd.c cli_cfg_main.c cli_power_cmd.c
  group bqb
    ../../../src/sample/rws/bqb/: bqb_main.c bqb_cmd.c
  group ble
    ../../../src/ble/profile/client/: ancs_client.c ams_client.c
    ../../../src/sample/common/app_ble_service/: transmit_service.c ota_service.c
    ../../../src/ble/profile/server/: bas.c dis.c
    ../../../src/ble/gatt_client/: gattc_tbl_storage.c bt_ext_ftl.c
    ../../../src/ble/bt_gatt_svc/: transmit_svc_dongle.c
  group xiaoai
    ../../../src/sample/rws/xiaoai/: app_xm_xiaoai.c app_xiaoai_device.c app_xiaoai_record.c app_xm_xiaoai_ble_adv.c app_xiaoai_transport.c app_xm_xiaoai_rfc.c app_xiaoai_ota.c app_xiaoai_ota_flash.c app_xiaoai_rcsp.c xm_auth.c
  group xiaowei
    ../../../src/sample/rws/xiaowei/: app_xiaowei.c app_xiaowei_ble_adv.c app_xiaowei_device.c app_xiaowei_record.c app_xiaowei_rfc.c app_xiaowei_transport.c
  group app
    ../../../src/sample/rws/: app_main.c app_util.c app_cfg.c app_io_msg.c app_led.c app_key_gpio.c app_key_process.c app_charger.c app_transfer.c app_report.c app_gap.c app_ble_gap.c app_ble_device.c app_ble_client.c app_ble_service.c app_ble_common_adv.c app_sdp.c app_hfp.c app_avrcp.c app_a2dp.c app_pbap.c app_iap.c app_roleswap.c app_relay.c app_device.c app_mmi.c app_dlps.c app_link_util.c app_linkback.c app_multilink.c app_bt_policy.c app_audio_policy.c app_gpio_on_off.c app_rdtp.c app_test.c app_anc.c app_eq.c app_nfc.c app_sensor_i2c.c app_sensor.c app_ota.c app_bt_policy_api.c app_in_out_box.c app_vad.c app_iap_rtk.c app_buzeer.c app_bond.c app_third_party_srv.c app_bt_sniffing.c app_audio_passthrough.c app_adp.c app_io_output.c app_console_msg.c app_cap_touch.c app_spp.c app_cmd.c app_listening_mode.c app_sensor_px318j.c app_auto_power_off.c app_line_in.c app_airplane.c app_adc.c app_ble_swift_pair.c app_audio_route.c app_hid.c app_qol.c app_ota_tooling.c app_hearable.c app_slide_switch.c app_sniff_mode.c app_ble_bond.c app_sensor_jsa.c rtk_charger.c app_audio_passthrough_brightness.c app_one_wire_uart.c app_bud_loc.c app_single_multilink_customer.c app_hfp_ag.c app_rtk_fast_pair_adv.c app_ble_rand_addr_mgr.c app_roleswap_control.c app_amp.c app_ipc.c app_adp_cmd.c app_adp_cmd_parse.c app_sensor_mems.c app_loc_mgr.c app_tts.c app_ble_sc_key_derive.c app_console.c app_qdec.c app_ble_whitelist.c app_vendor.c app_usb_suspend.c app_sass_policy.c app_audio_hearing.c app_ble_gatt_caching.c app_ext_mic_switch.c
    ../../../src/sample/common/: app_dsp_cfg.c app_data_capture.c app_sidetone.c app_cfu_transfer.c app_common_cfu.c app_nrec.c app_usb_vol_control.c
    ../../../src/sample/rws/eq/: eq_utils.c eq_ext_ftl.c app_eq_fitting.c app_eq_coeff.c
    ../../../src/sample/rws/usb/: app_usb.c
    ../../../src/sample/rws/usb/audio/: app_usb_audio.c
    ../../../src/sample/rws/usb/hid/: app_usb_mmi.c app_usb_hid_cmd.c
    ../../../src/sample/rws/dongle/: app_dongle_dual_mode.c
    ../../../src/sample/rws/ha/: ha_ext_ftl.c
    ../../../src/sample/rws/speaker/: app_multilink_customer.c
    ../../../src/ble/bt_gatt_svc/: hids_cfu.c
  group mp
    ../../../src/sample/rws/mp/: cli_mp_main.c mp_test.c mp_test_vendor.c single_tone.c
  group gfps
    ../../../src/sample/rws/gfps/: app_gfps.c app_gfps_account_key.c app_gfps_device.c app_gfps_personalized_name.c app_gfps_rfc.c app_ecc.c app_gfps_battery.c app_gfps_sync.c app_gfps_link.c app_gfps_msg.c app_gfps_psm.c app_gfps_finder.c app_gfps_finder_adv.c app_gfps_finder_test_internal.c app_gfps_timer.c
  group ama
    ../../../src/sample/rws/ama/: app_ama.c app_ama_accessory.c app_ama_ble.c app_ama_device.c app_ama_record.c app_ama_roleswap.c app_ama_spp.c app_ama_timer.c app_ama_transport.c app_ama_tone.c
  group teams
    ../../../src/sample/rws/teams/asp_device/: app_asp_device.c app_asp_device_rfc.c
    ../../../src/sample/rws/teams/hid/: app_hid_rfc.c app_teams_hid.c
    ../../../src/sample/rws/teams/: app_teams_rws.c app_teams_audio_policy.c app_teams_bt_policy.c app_teams_cmd.c app_teams_customized_cmd.c app_teams_extend_led.c app_teams_util.c app_teams_ext_ftl.c app_teams_ble_policy.c
    ../../../src/sample/rws/teams/cfu/Signature/: CryptoInterface.c ProdCA.S TestCA.S
  group tuya
    ../../../src/sample/rws/tuya/rtk_tuya_ble_app/: rtk_tuya_app_product_test.c rtk_tuya_app_uart_common_handler.c rtk_tuya_app_ext_ftl.c rtk_tuya_ble_adv.c rtk_tuya_ble_app_demo.c rtk_tuya_ble_device.c rtk_tuya_ble_service.c rtk_tuya_app_relay.c rtk_tuya_app_dp.c rtk_tuya_ble_ota.c rtk_tuya_ble_ota_flash.c
    ../../../src/sample/rws/tuya/tuya_enc/mbedtls/: rtk_tuya_aes_test.c md5.c sha1.c sha256.c hmac.c
    ../../../src/sample/rws/tuya/rtk_tuya_ble_port/: rtk_tuya_ble_port_rtl8773c.c
    ../../../src/sample/rws/tuya/tuya_ble_sdk/: tuya_ble_api.c tuya_ble_app_production_test.c tuya_ble_app_uart_common_handler.c tuya_ble_bulk_data.c tuya_ble_data_handler.c tuya_ble_event.c tuya_ble_event_handler.c tuya_ble_event_handler_weak.c tuya_ble_feature_weather.c tuya_ble_gatt_send_queue.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_mutli_tsf_protocol.c tuya_ble_port.c tuya_ble_port_peripheral.c tuya_ble_queue.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_utils.c
  group lea
    ../../../src/sample/rws/lea/: app_lea_adv.c app_lea_ascs.c app_lea_ccp.c app_lea_csis.c app_lea_mcp.c app_lea_pacs.c app_lea_scan.c app_lea_vcs.c app_lea_mgr.c app_lea_profile.c cli_le_audio.c app_lea_realcast.c app_lea_unicast_audio.c app_lea_vol_policy.c app_lea_broadcast_audio.c app_lea_mics.c
  group dongle
    ../../../src/sample/rws/dongle/: app_dongle_record.c app_dongle_spp.c app_dongle_common.c app_dongle_source_ctrl.c app_dongle_data_ctrl.c app_dongle_customized_vp.c app_dongle_controller.c app_dongle_audio.c
    ../../../src/sample/common/: app_gaming_sync.c
    ../../../src/sample/rws/: app_ble_hid_controller.c
  group bond
    ../../../src/sample/rws/bond/: ble_audio_bond.c ble_bond_sync.c
  group vendor_sensor
    ../../../src/sample/rws/vendor/sensor/mems/inv_42607/imu/: inv_imu_driver.c inv_imu_transport.c
  group usb
    ../../../src/sample/rws/usb/audio/: usb_audio_stream.c usb_audio1.c usb_audio2.c
    ../../../src/sample/rws/usb/hid/: usb_hid.c
    ../../../src/sample/rws/usb/: usb_dev.c
    ../../../src/sample/common/usb/: usb_host_detect.c
  group mtc
    ../../../src/app/multitopology/: multitopology_bw_prio.c multitopology_ctrl.c multitopology_if.c multitopology_pro.c
  group findmy
    ../../../src/sample/rws/findmy/: app_findmy.c app_findmy_ble_adv.c app_findmy_rws.c app_findmy_task.c ancs.c peer_manager.c
    ../../../src/sample/rws/findmy/fmna/: fmna_adv.c fmna_config_control_point.c fmna_connection.c fmna_crypto.c fmna_debug_control_point.c fmna_motion_detection.c fmna_nfc.c fmna_gatt.c fmna_nonowner_control_point.c fmna_paired_owner_control_point.c fmna_pairing_control_point.c fmna_state_machine.c fmna_version.c
    ../../../src/sample/rws/findmy/fmna/platform/: fmna_adv_platform.c fmna_battery_platform.c fmna_connection_platform.c fmna_fault_platform.c fmna_gatt_platform.c fmna_malloc_platform.c fmna_motion_detection_platform.c fmna_nfc_platform.c fmna_peer_manager.c fmna_sound_platform.c fmna_timer_platform.c
    ../../../src/sample/rws/findmy/ble_platform/: platform_list.c
    ../../../src/sample/rws/findmy/ble_profile/: accessory_info_service.c findmy_network_service.c
    ../../../src/ble/profile/server/: tps.c
    ../../../src/sample/common/findmy/crypto/fmna-crypto-wrapper-reference/src/: fm-crypto.c
    ../../../src/sample/common/findmy/crypto/wolfssl/wolfcrypt/src/: aes.c asn.c coding.c ecc.c hash.c hmac.c integer.c random.c sha256.c tfm.c wc_port.c wolfmath.c
    ../../../src/sample/common/findmy/crypto/third-party/mbedtls/: base64.c
  group test
    ../../../src/sample/rws/test/: app_power_test.c
target rws_4M_dual_bank1_ANC_Gaming (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: rws
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1  flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8763EWM = 1 TARGET_LEGACY_AUDIO_GAMING=1
  c misc: as above
  c include: .\inc\rtl87x3e_ewm;..\rws;..\..\..\inc\app;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\stack;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\platform;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\platform\console;..\..\..\inc\framework;..\..\..\inc\framework\sys;..\..\..\inc\framework\audio;..\..\..\inc\framework\mmi;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\rtl87x3e\hal;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\leaudio;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\service;..\..\..\inc\service\gfps;..\..\..\inc\service\bisto;..\..\..\inc\service\xiaoai;..\..\..\inc\service\xiaowei;..\..\..\inc\service\ama;..\..\..\inc\service\teams;..\..\..\inc\service\teams\asp_device;..\..\..\inc\service\teams\hid;..\..\..\inc\service\teams\ble;..\..\..\src\mcu\module\led;..\..\..\inc\hal\power;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\mcu\rtl876x;..\..\..\src\mcu\module\vector;..\..\..\src\mcu\module\stream;..\..\..\src\mcu\usb\inc;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\ble\gatt_client;..\..\..\src\debug;..\..\..\src\sample\rws;..\..\..\src\sample\rws\local_playback;..\..\..\src\sample\rws\local_playback\sd_emmc;..\..\..\src\sample\rws\bqb;..\..\..\src\sample\rws\console;..\..\..\src\sample\rws\cli;..\..\..\src\sample\rws\bud;..\..\..\src\sample\rws\mp;..\..\..\src\sample\rws\app;..\..\..\src\sample\rws\engage;..\..\..\src\sample\rws\gfps;..\..\..\src\sample\rws\xiaoai;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\bisto;..\..\..\src\sample\rws\ama;..\..\..\src\sample\rws\eq;..\..\..\src\sample\rws\dongle;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\teams\asp_device;..\..\..\src\sample\rws\teams\hid;..\..\..\src\sample\rws\teams;..\..\..\src\sample\rws\teams\cfu;..\..\..\src\sample\rws\teams\cfu\Signature;..\..\..\src\sample\rws\xiaowei;..\..\..\src\sample\rws\lea;..\..\..\src\sample\rws\usb_audio;..\..\..\src\sample\rws\usb_cfu;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\ble_mgr;..\..\..\src\sample\rws\usb;..\..\..\src\sample\rws\usb\audio;..\..\..\src\sample\rws\usb\hid;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_app;..\..\..\src\sample\rws\tuya\tuya_enc\mbedtls;..\..\..\src\sample\rws\tuya\rtk_tuya_ble_port;..\..\..\src\sample\rws\tuya\tuya_ble_sdk;..\..\..\src\sample\rws\tuya\tuya_enc;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\io;..\..\..\src\mcu\module\console\transport;..\..\..\src\sample\rws\ha;..\..\..\src\sample\rws\speaker;..\..\..\inc\hal\platform;..\..\..\src\sample\rws\findmy;..\..\..\src\sample\rws\findmy\fmna;..\..\..\src\sample\rws\findmy\fmna\platform;..\..\..\src\sample\rws\findmy\ble_platform;..\..\..\src\sample\common\findmy\crypto\third_party\mbedtls;..\..\..\src\sample\common\findmy\crypto\fmna-crypto-wrapper-reference\include;..\..\..\src\sample\common\findmy\crypto;..\..\..\src\sample\common\findmy\crypto\wolfssl\wolfcrypt\src;..\..\..\src\sample\common\findmy\crypto\wolfssl\wolfssl\wolfcrypt;..\..\..\src\sample\common\findmy\crypto\third-party;..\..\..\src\sample\common\findmy\crypto\wolfssl;..\..\..\src\sample\rws\findmy\ble_profile;..\..\..\src\sample\rws\test;..\..\..\src\sample\common;..\..\..\inc\rtl87x3e\hal\stack;..\..\..\src\ble\bt_gatt_svc;..\..\..\inc\ble_mgr\bond;..\..\..\inc\usb;..\..\..\inc\usb\bc12;..\..\..\inc\usb\class;..\..\..\inc\usb\composite;..\..\..\inc\usb\hal;..\..\..\src\sample\common\app_ble_service;..\..\..\src\sample\rws\lea;..\..\..\src\sample\rws\bond;..\..\..\src\sample\common\usb
  asm misc: --cpreproc
  asm include: .\inc\rtl87x3e_ewm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\cfg\rtl87x3e\rtl87x3e_rws_ewm_bank1.sct
  link misc: --diag_suppress=L6314 --datacompressor off
