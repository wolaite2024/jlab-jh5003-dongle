# Keil uVision project remote.uvprojx, settings and files
target rtl87x3e (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: remote +hex (library)
  AfterMake: cmd.exe /c remote_after_build.bat 3e && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_REALTEK_REMOTE_CONTROL_SUPPORT=1
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\framework\remote;..\..\..\..\src\framework\sys;..\..\..\..\src\framework\btm;..\..\..\..\inc\framework\bt;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group src
    ../../../../src/framework/remote/: remote_mgr.c
