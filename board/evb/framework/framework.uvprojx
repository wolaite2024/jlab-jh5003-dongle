# Keil uVision project framework.uvprojx, settings and files
target rtl87x3e_all (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: framework +hex (library)
  AfterMake: cmd.exe /c framework_after_build.bat 3e all && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: F_BT_LE_5_0_AE_ADV_SUPPORT=1 CONFIG_SOC_SERIES_RTL8763E CONFIG_REALTEK_BTM_HID_DEVICE_SUPPORT=1 CONFIG_REALTEK_BTM_HID_HOST_SUPPORT=0  CONFIG_REALTEK_BTM_IAP_SUPPORT=1 CONFIG_REALTEK_BTM_MAP_SUPPORT=1 CONFIG_REALTEK_BTM_ROLESWAP_SUPPORT=1 CONFIG_REALTEK_BTM_PBAP_SUPPORT=1 CONFIG_REALTEK_BTM_ATT_SUPPORT=1 CONFIG_REALTEK_BTM_A2DP_SUPPORT=1 CONFIG_REALTEK_BTM_AVRCP_SUPPORT=1 CONFIG_REALTEK_BTM_AVRCP_BROWSING_SUPPORT=1 CONFIG_REALTEK_BTM_AVRCP_COVER_ART_SUPPORT=1 CONFIG_REALTEK_BTM_HFP_AG_SUPPORT=1 CONFIG_REALTEK_BTM_HFP_SUPPORT=1 CONFIG_REALTEK_AM_LINE_IN_SUPPORT=1 CONFIG_REALTEK_AM_AUDIO_PIPE_SUPPORT=1 CONFIG_REALTEK_LISTEN_WHILE_SAVE_SUPPORT=1 CONFIG_REALTEK_AM_ANC_SUPPORT=1 CONFIG_REALTEK_AM_AUDIO_PLUGIN_SUPPORT=1 CONFIG_REALTEK_REMOTE_CONTROL_SUPPORT=1 F_APP_EXT_MIC_SWITCH_SUPPORT=1
  c misc: --gnu --bss_threshold=0  --no_branch_tables
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\framework\sys;..\..\..\inc\framework\audio;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\src\framework\sys;..\..\..\src\framework\btm\gatt;..\..\..\src\framework\btm;..\..\..\src\framework\audiomgr;..\..\..\src\framework\audiohal;..\..\..\src\framework\audiohal\dsp;..\..\..\src\framework\audiohal\codec;..\..\..\src\framework\audiohal\sport;..\..\..\src\framework\audiohal\anc;..\..\..\inc\rtl87x3e\io;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\platform;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\src\mcu\rtl876x;..\..\..\inc\rtl87x3e\hal;..\..\..\inc\rtl87x3e\hal\audio;..\..\..\inc\rtl87x3e\hal\stack;..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\io;..\..\..\inc\hal\audio;..\..\..\inc\bluetooth\profile;..\..\..\inc\hal\platform
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group profile
    ../../../src/framework/btm/: a2dp.c avctp.c avdtp.c avrcp.c hfp.c obex.c pbap.c spp.c rfc.c iap.c rdtp.c avp.c avp_att.c hfp_ag.c hid_device.c hid_host.c hid_parser.c map.c iap_cp.c att_br.c opp.c
  group btmgr
    ../../../src/framework/btm/: bt_mgr.c bt_pm.c bt_gap.c bt_sdp.c bt_a2dp.c bt_hfp.c bt_spp.c bt_pbap.c bt_iap.c bt_avrcp.c bt_rdtp.c bt_rfc.c bt_avp.c bt_roleswap.c bt_roleswap_sniffing.c bt_hfp_ag.c bt_hid_device.c bt_hid_host.c bt_map.c bt_att.c bt_opp.c
  group audiomgr
    ../../../src/framework/audiomgr/: audio_mgr.c audio_probe.c audio_remote.c audio_track.c audio_volume.c notification.c ringtone.c voice_prompt.c tts.c eq.c vad.c anc.c nrec.c media_buffer.c media_pool.c record_buffer.c audio_path.c jitter_buffer.c audio_passthrough.c audio_effect.c audio_interval_eval.c line_in.c notification_buffer.c wdrc.c audio_pipe.c sidetone.c listen_save_buffer.c anc_tuning.c audio_plugin.c audio_latency.c audio_codec.c sys_cfg.c
  group audiohal
    ../../../src/framework/audiohal/dsp/: dsp_ipc.c dsp_loader.c dsp_mgr.c
    ../../../src/framework/audiohal/codec/: codec_mgr.c
    ../../../src/framework/audiohal/: audio_route.c
    ../../../src/framework/audiohal/sport/: sport_mgr.c
    ../../../src/framework/audiohal/bin_load/: bin_loader.c
    ../../../src/framework/audiohal/anc/: anc_mgr.c anc_loader.c adsp_loader.c
target rtl87x3e_stereo (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: framework +hex (library)
  AfterMake: cmd.exe /c framework_after_build.bat 3e stereo && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: F_BT_LE_5_0_AE_ADV_SUPPORT=1 CONFIG_SOC_SERIES_RTL8763E CONFIG_REALTEK_BTM_HID_DEVICE_SUPPORT=1 CONFIG_REALTEK_BTM_HID_HOST_SUPPORT=0  CONFIG_REALTEK_BTM_AVP_SUPPORT=0 CONFIG_REALTEK_BTM_IAP_SUPPORT=1 CONFIG_REALTEK_BTM_MAP_SUPPORT=0 CONFIG_REALTEK_BTM_ROLESWAP_SUPPORT=0 CONFIG_REALTEK_BTM_PBAP_SUPPORT=1 CONFIG_REALTEK_BTM_A2DP_SUPPORT=1 CONFIG_REALTEK_BTM_AVRCP_SUPPORT=1 CONFIG_REALTEK_BTM_HFP_SUPPORT=1 CONFIG_REALTEK_AM_LINE_IN_SUPPORT=1 CONFIG_REALTEK_AM_AUDIO_PIPE_SUPPORT=1 CONFIG_REALTEK_LISTEN_WHILE_SAVE_SUPPORT=0 CONFIG_REALTEK_AM_ANC_SUPPORT=1 CONFIG_REALTEK_AM_AUDIO_PLUGIN_SUPPORT=1 CONFIG_REALTEK_AM_AUDIO_STEREO_SUPPORT = 1 CONFIG_REALTEK_REMOTE_CONTROL_SUPPORT=1 F_APP_EXT_MIC_SWITCH_SUPPORT=1
  c misc: --gnu --bss_threshold=0
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
