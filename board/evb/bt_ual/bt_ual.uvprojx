# Keil uVision project bt_ual.uvprojx, settings and files
target src_bb2_ccut (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: bt_ual +hex (library)
  AfterMake: cmd.exe /c bt_ual_after_build.bat 3e && echo %TIME%
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_PRIVACY_SPT=1, BLE_LOCAL_PRIVACY_SPT=0, RAM_TYPE_VECTOR=RAM_TYPE_DSPSHARE, RAM_TYPE_BT_UAL=RAM_TYPE_DSPSHARE, GATTC_TBL_STORAGE_SUPPORT=1
  c misc: --gnu --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\platform;..\..\..\inc\bluetooth\profile;..\..\..\src\app\bt_ual;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\src\mcu\rtl876x;..\..\..\src\framework\profile\bredr\gatt;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\src\app\bt_ual\inc_int;..\..\..\src\ble\gatt_client;..\..\..\src\mcu\module\vector;..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\inc\rtl87x3e\hal;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\ble_mgr;..\..\..\inc\hal\platform
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\bt_bal.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group ual
    ../../../src/app/bt_ual/: ual_adapter.c scan_mgr.c inquiry.c ual_dev_mgr.c connection_mgr.c ble_privacy.c adv_mgr.c ble_legacy_adv.c ble_extend_adv.c ble_sc_key_derive.c ble_pa_sync.c bt_storage_mgr.c ble_bg_conn.c ble_direct_conn.c
    ../../../src/mcu/module/vector/: vector.c
    ../../../src/ble/gatt_client/: bt_ext_ftl.c gattc_tbl_storage.c
