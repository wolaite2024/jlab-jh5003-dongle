# Keil uVision project usb_lib.uvprojx, settings and files
target rtl87x3e (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: usb (library)
  AfterMake: cmd.exe /c usb_lib_after_build.bat 3e && echo %TIME%
  c flags: Optim=3 uC99=1 wLevel=2
  c define: CONFIG_SOC_SERIES_RTL8763E
  c misc: --gnu --bss_threshold=0 --preinclude port_macro.h
  c include: ..\..\..\inc\usb\hal;..\..\..\inc\rtl87x3e\io;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\usb;..\..\..\inc\usb\composite;..\..\..\inc\usb\class;..\..\..\src\sample\rws\usb\audio;..\..\..\src\mcu\usb\lib\isr;..\..\..\src\mcu\usb\lib\dm;..\..\..\src\mcu\usb\lib\task;..\..\..\inc\hal\io;..\..\..\inc\hal\platform;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\os;..\..\..\inc\platform;..\..\..\src\mcu\usb\lib\class\mass_storage;..\..\..\inc\usb\bc12;..\usb_lib;..\..\..\inc\rtl87x3e\hal
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6314 --datacompressor off
  group composite
    ../../../src/mcu/usb/lib/composite/: usb_composite_dev.c usb_dev_driver.c
    ../../../src/mcu/usb/lib/class/audio/: usb_audio_driver.c
    ../../../src/mcu/usb/lib/class/hid/: usb_hid_driver.c
    ../../../src/mcu/usb/lib/class/mass_storage/: usb_ms_driver.c usb_ms_scsi.c
    ../../../src/mcu/usb/lib/class/gip/: usb_gip_driver.c
    ../../../src/mcu/usb/lib/class/cdc/: usb_cdc_driver.c
  group dm
    ../../../src/mcu/usb/lib/dm/: usb_dm.c
  group isr
    ../../../src/mcu/usb/lib/isr/: usb_isr.c
  group pipe
    ../../../src/mcu/usb/lib/pipe/: usb_pipe.c
  group task
    ../../../src/mcu/usb/lib/task/: usb_task.c
