# Keil uVision project gaming_dongle_rtl87x3e.uvprojx, settings and files
target dongle_bank0_bb2_ccut_legacy_gaming (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: dongle
  BeforeMake: cmd.exe /c before_build_script.bat 4M "0" rtl87x3e dongle gaming_dongle
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank0 rtl87x3e gaming_dongle
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8763EAU, CONFIG_SOC_SERIES_RTL8763E_V2=1, UAL_CONSOLE_PRINT=0, APP_DEBUG_REPORT=0, UAL_LATENCY_TEST=0,SUPPORT_ACCESS_SHM=1,RAM_TYPE_GATT_CLIENT=RAM_TYPE_DSPSHARE, RAM_TYPE_VECTOR=RAM_TYPE_DSPSHARE, LEGACY_BT_GAMING,APP_PID=2100, TARGET_LEGACY_GAMING_DONGLE=1
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\dongle;..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\framework;..\..\..\inc\framework\sys;..\..\..\inc\framework\audio;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\platform;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\stack;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\platform\console;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\mcu\module\led;..\..\..\src\sample\gaming_dongle;..\..\..\src\sample\gaming_dongle\bqb;..\..\..\src\sample\gaming_dongle\console;..\..\..\src\sample\gaming_dongle\cli;..\..\..\src\sample\gaming_dongle\mp;..\..\..\src\sample\gaming_dongle\legacy_bt;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\mcu\rtl87x3;..\..\..\src\mcu\module\stream;..\..\..\src\framework\platform;..\..\..\inc\service;..\..\..\src\mcu\module\vector;..\..\..\inc\rtl87x3e\hal;..\..\..\src\rtl87x3e\hal\wrapper;..\..\..\src\sample\gaming_dongle\usb;..\..\..\src\app\ble_audio_dongle;..\..\..\src\mcu\module\vector;..\..\..\src\mcu\usb\inc;..\..\..\src\framework\audiomgr;..\..\..\src\app\bt_ual;..\..\..\src\ble\gatt_client;..\..\..\src\sample\gaming_dongle\ual;..\..\..\src\sample\gaming_dongle\le_bt;..\..\..\src\sample\gaming_dongle\le_bt\le_audio_service;..\..\..\src\app\bt_ual;..\..\..\src\app\bt_ual\inc_int;..\..\..\inc\bluetooth\gap\le;..\..\..\inc\bluetooth\leaudio;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\src\sample\gaming_dongle\general_bt;..\..\..\src\sample\gaming_dongle\cfu;..\..\..\inc\ble_mgr;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\io;..\..\..\src\mcu\module\console\transport;..\..\..\inc\hal\platform;..\..\..\inc\usb;..\..\..\inc\usb\bc12;..\..\..\inc\usb\class;..\..\..\inc\usb\composite;..\..\..\inc\usb\hal;..\..\..\src\sample\gaming_dongle\usb\hid;..\..\..\src\sample\gaming_dongle\usb\audio;..\..\..\src\ble\bt_gatt_client;..\..\..\src\app\ble_audio_lib\util;..\..\..\inc\ble_mgr;..\..\..\src\sample\common;..\..\..\src\mcu\module\eq;..\..\..\inc\hal\power;..\..\..\src\sample\common\app_ble_service;..\..\..\src\sample\common\usb
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\dongle_bank0_rtl87x3e.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../inc/rtl87x3e/platform/: rom_uuid.h
    ./: config.h
  group lib
    ../../../bin/rtl87x3e/: gap_utils.lib leaudio.lib usb_hal.lib usb.lib bt_ual.lib upperstack_4M.lib ROM.lib framework.lib hal_utils.lib gaming_bt.lib dongle_teams.lib ble_mgr.lib audio_adaptor.lib
    ../../../bin/rtl87x3e/framework/: console.lib sysm.lib remote.lib
  group cmsis
    ../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group module
    ../../../src/mcu/module/led/: led_module.c
    ../../../src/mcu/module/stream/: ble_stream.c iap_stream.c spp_stream.c common_stream.c
  group console
    ../../../src/mcu/module/console/transport/: console_uart.c
  group cli
    ../../../src/sample/gaming_dongle/cli/: cli_cfg_cmd.c cli_cfg_main.c cli_power_cmd.c
    ../../../src/sample/gaming_dongle/: app_cli_main.c
  group mp
    ../../../src/sample/gaming_dongle/mp/: cli_mp_main.c single_tone.c
  group bqb
    ../../../src/sample/gaming_dongle/bqb/: bqb_main.c bqb_cmd.c
  group app
    ../../../src/sample/gaming_dongle/: app_main.c app_util.c app_cfg.c app_io_msg.c app_key_gpio.c app_device.c app_mmi.c app_link_util.c app_io_output.c app_dlps.c app_key_process.c app_console_msg.c app_auto_power_off.c app_led_ctl.c app_cyclic_buffer.c app_status_report.c app_dongle_vol.c app_line_in.c app_console.c app_ctrl_pkt_policy.c app_charger.c rtk_charger.c app_dongle_transmit_client.c app_sensor_i2c.c app_upstream_decode.c app_audio_pipe_mgr.c app_downstream_encode.c app_ipc.c
    ../../../src/sample/common/: app_dsp_cfg.c app_gaming_sync.c app_usb_vol_control.c
    ../../../src/sample/gaming_dongle/audio_test/: audio_test.c
    ../../../src/sample/gaming_dongle/legacy_bt/: app_spp_audio.c
    ../../../src/sample/gaming_dongle/gip/: app_gip.c app_gip_security.c
  group app_legacy_bt
    ../../../src/sample/gaming_dongle/legacy_bt/: app_a2dp.c app_avrcp.c app_bond.c app_gap.c app_sdp.c app_spp.c legacy_audio_wrapper.c app_gaming_ctrl_cfg.c app_src_policy.c app_src_gaming.c
  group usb
    ../../../src/sample/gaming_dongle/usb/: app_usb.c app_usb_hid.c app_usb_passthrough.c app_usb_uac.c app_usb_hid_wrapper.c app_usb_audio_wrapper.c usb_dev.c uac_silence_detect.c app_hid_rtk_ctrl.c app_usb_controller.c
    ../../../src/sample/gaming_dongle/usb/hid/: usb_hid.c
    ../../../src/sample/gaming_dongle/usb/audio/: usb_audio1.c usb_audio1_sec.c usb_audio2.c usb_audio_stream.c
    ../../../src/sample/gaming_dongle/usb/gip/: usb_gip.c
    ../../../src/sample/common/usb/: usb_host_detect.c
  group ual
    ../../../src/sample/gaming_dongle/ual/: app_adapter_service.c app_usb_layer.c cli_console_cmd.c
  group cfu
    ../../../src/sample/gaming_dongle/cfu/: app_cfu.c dfu_common.c
    ../../../src/sample/gaming_dongle/usb/: app_cfu_passthrough.c
  group le_bt
    ../../../src/sample/gaming_dongle/le_bt/le_audio_service/: le_audio_lib_msg.c le_audio_service.c le_bst_src_service.c le_media_player.c le_audio_data.c le_ba_service.c le_bsk_service.c le_csis_client_service.c le_vc_service.c teams_call_control.c le_pacs_service.c le_unicast_sink_service.c le_unicast_src_service.c le_bass_service.c le_csis_srv_service.c le_vcs_service.c le_media_controller.c le_mic_service.c le_unicast_gaming.c
    ../../../src/sample/gaming_dongle/le_bt/: le_service_mgr.c le_broadcast_mgr.c le_audio_wrapper.c
    ../../../src/ble/bt_gatt_client/: dongle_transmit_gatt_client.c
  group app_le_bt
    ../../../src/sample/gaming_dongle/le_bt/: app_le_audio.c app_le_ext_ftl.c
  group app_general_bt
    ../../../src/sample/gaming_dongle/general_bt/: app_ctrl_cfg.c app_hfp_ag.c app_usb_call_control.c app_sdp_a2dp_src.c app_spp_vender_passthrough.c app_src_a2dp.c app_src_audio.c app_src_ll.c app_src_storage_target_dev.c app_vendor_cfg.c app_general_policy.c general_audio_wrapper.c
    ../../../src/sample/gaming_dongle/: app_spp_cmd.c
  group gip
    ../../../src/service/gip/: GipCore.c GipDevice.c GipIf.c GipSystem.c
target dongle_bank1_bb2_ccut_legacy_gaming (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: dongle
  BeforeMake: as above
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe"   "#L"  @L  bank1 rtl87x3e gaming_dongle
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\dongle;..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\rtl87x3e\os;..\..\..\inc\rtl87x3e\io;..\..\..\inc\framework;..\..\..\inc\framework\sys;..\..\..\inc\framework\audio;..\..\..\inc\framework\bt;..\..\..\inc\framework\remote;..\..\..\inc\framework\console;..\..\..\inc\rtl87x3e\platform;..\..\..\inc\platform;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\stack;..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\inc\rtl87x3e\platform\console;..\..\..\src\ble\adv_mgr;..\..\..\src\ble\ble_conn_update;..\..\..\src\mcu\module\led;..\..\..\src\sample\gaming_dongle;..\..\..\src\sample\gaming_dongle\bqb;..\..\..\src\sample\gaming_dongle\console;..\..\..\src\sample\gaming_dongle\cli;..\..\..\src\sample\gaming_dongle\mp;..\..\..\src\sample\gaming_dongle\legacy_bt;..\..\..\src\mcu\legacy\spp_ota;..\..\..\src\mcu\rtl87x3;..\..\..\src\mcu\module\stream;..\..\..\src\framework\platform;..\..\..\inc\service;..\..\..\src\mcu\module\vector;..\..\..\inc\rtl87x3e\hal;..\..\..\src\rtl87x3e\hal\wrapper;..\..\..\src\sample\gaming_dongle\usb;..\..\..\src\app\ble_audio_dongle;..\..\..\src\mcu\module\vector;..\..\..\src\mcu\usb\inc;..\..\..\src\framework\audiomgr;..\..\..\src\app\bt_ual;..\..\..\src\ble\gatt_client;..\..\..\src\sample\gaming_dongle\ual;..\..\..\src\sample\gaming_dongle\le_bt;..\..\..\src\sample\gaming_dongle\le_bt\le_audio_service;..\..\..\src\app\bt_ual;..\..\..\src\app\bt_ual\inc_int;..\..\..\inc\bluetooth\gap\le;..\..\..\inc\bluetooth\leaudio;..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\src\sample\gaming_dongle\general_bt;..\..\..\inc\app;..\..\..\src\app\ota;..\..\..\src\sample\gaming_dongle\cfu;..\..\..\inc\ble_mgr;..\..\..\inc\rtl87x3e\hal\io;..\..\..\inc\hal\io;..\..\..\src\mcu\module\console\transport;..\..\..\inc\hal\platform;..\..\..\inc\usb;..\..\..\inc\usb\bc12;..\..\..\inc\usb\class;..\..\..\inc\usb\composite;..\..\..\inc\usb\hal;..\..\..\src\sample\gaming_dongle\usb\hid;..\..\..\src\sample\gaming_dongle\usb\audio;..\..\..\src\ble\bt_gatt_client;..\..\..\src\app\ble_audio_lib\util;..\..\..\inc\ble_mgr;..\..\..\src\sample\common;..\..\..\src\mcu\module\eq;..\..\..\inc\hal\power;..\..\..\src\sample\common\app_ble_service;..\..\..\src\sample\common\usb
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\dongle_bank1_rtl87x3e.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target dongle_bank0_bb2_ccut_gaming_dual_uac (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: dongle
  BeforeMake: as above
  AfterMake: as above
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8763EAU, CONFIG_SOC_SERIES_RTL8763E_V2=1, UAL_CONSOLE_PRINT=0, APP_DEBUG_REPORT=0, UAL_LATENCY_TEST=0,SUPPORT_ACCESS_SHM=1,RAM_TYPE_GATT_CLIENT=RAM_TYPE_DSPSHARE, RAM_TYPE_VECTOR=RAM_TYPE_DSPSHARE, DONGLE_LE_AUDIO=1, LEGACY_BT_GAMING, APP_PID=2100, ENABLE_UAC2, TARGET_LEGACY_GAMING_DONGLE=1
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\dongle_bank0_rtl87x3e.sct
  link misc: --diag_suppress=L6314 --datacompressor off
target dongle_bank1_bb2_ccut_gaming_dual_uac (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: dongle
  BeforeMake: as above
  AfterMake: as above
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\dongle_bank1_rtl87x3e.sct
  link misc: --diag_suppress=L6314 --datacompressor off
