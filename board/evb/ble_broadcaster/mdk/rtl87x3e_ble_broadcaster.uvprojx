# Keil uVision project rtl87x3e_ble_broadcaster.uvprojx, settings and files
target ble_broadcaster_4M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_broadcaster
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 4M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe" "#L" @L bank0 flash_4M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8753EFE = 1
  c misc: --gnu --preinclude app_broadcaster_flags.h --bss_threshold=0
  c include: ..\..\ble_broadcaster;..\mdk;..\inc\rtl87x3e;..\..\..\..\src\sample\ble_broadcaster;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\hal\platform;..\..\..\..\src\framework\sys
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_ble_broadcaster_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
  group include
    ../../../../inc/rtl87x3e/platform/: rom_uuid.h
  group lib
    ../../../../bin/rtl87x3e/: ROM.lib upperstack_4M.lib hal_utils.lib ble_mgr.lib gap_utils.lib
    ../../../../bin/rtl87x3e/framework/: sysm.lib
  group cmsis
    ../../../../src/mcu/rtl87x3/arm/: startup_rtl87x3e.s
    ../../../../src/mcu/rtl87x3/: system_rtl87x3.c
  group app
    ../../../../src/sample/ble_broadcaster/: app_broadcaster_adv.c app_broadcaster_gap.c app_broadcaster_main.c app_broadcaster_task.c
target ble_broadcaster_16M_bank0 (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: ble_broadcaster
  BeforeMake: cmd.exe /c rtl87x3e_before_build_script.bat 16M rtl87x3e all
  AfterMake: cmd.exe /c dual_bank_after_build.bat "$J\..\bin\fromelf.exe" "#L" @L bank0 flash_16M_dualbank rtl87x3e
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_RTL8753EFE = 1
  c misc: --gnu --preinclude app_broadcaster_flags.h --bss_threshold=0
  c include: ..\..\ble_broadcaster;..\mdk;..\..\..\..\src\sample\ble_broadcaster;..\inc\rtl87x3e;..\..\..\..\inc\rtl87x3e\platform;..\..\..\..\inc\platform;..\..\..\..\inc\rtl87x3e\platform\cmsis;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\rtl87x3e\os;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\app;..\..\..\..\inc\rtl87x3e\io;..\..\..\..\inc\rtl87x3e\hal;..\..\..\..\bin\rtl87x3e\upperstack_stamp;..\..\..\..\bin\rtl87x3e\flash_map_config;..\..\..\..\inc\rtl87x3e\bluetooth\gap;..\..\..\..\inc\ble_mgr;..\..\..\..\inc\hal\platform;..\..\..\..\src\framework\sys
  asm misc: --cpreproc
  asm include: .\inc\rtl87x3e
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\rtl87x3e\rtl87x3e_ble_broadcaster_bank0.sct
  link misc: --diag_suppress=L6314 --datacompressor off
